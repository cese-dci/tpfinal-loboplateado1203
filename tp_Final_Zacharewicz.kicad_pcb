# Repository cese-dci/tpfinal-loboplateado1203

File README.md:

# tpfinal-loboplateado1203
tpfinal-loboplateado1203 created by GitHub Classroom
TP Final : Diseño de Circuitos Impresos 

Poncho Drivers EDU-CIAA. 

Pensado para  el manejo de motores PAP, con el fin de diseñar un prototipo, de un máquina  destinada para doblar alambre 
/ caños.
Se diseñar una placa, para implementar la utilización de tres drivers,destinada al manejo de motores paso a paso y a su vez, 
se deja dispuesto un conector par la utilización de un teclado, para comunicarse con la dobladora de alambre. Por  dicho 
teclado se ingresan los grados y el sentido, en que debe girar el motor para realizar el diseño esperado.
El poncho realizado para esta materia forma parte del trabajo final de la especialización  - CESE 8va cohorte.

Autor
Lic. Zacharewicz L.B.

## KiCad design tp_Final_Zacharewicz.kicad_pcb

Parts:
A1, A2, A3: Pololu_DRV8825; Pololu_Breakout-16_15.2x20.3mm
C1, C2, C3: 100 uf; CP_Radial_D4.0mm_P2.00mm
C4, C5: 0.47 uf; C_Disc_D4.3mm_W1.9mm_P5.00mm
C7: 10uf; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal
J1: Motor 1; PinHeader_1x04_P2.54mm_Vertical
J2: Motor 2; PinHeader_1x04_P2.54mm_Vertical
J3: Motor 3; PinHeader_1x04_P2.54mm_Vertical
J4, J5, J6: Conn_02x03; PinHeader_2x03_P2.54mm_Vertical
J7: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical
J8: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J9: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R1: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
U1: LM7805; TO-220-3_Vertical
U2: PIC16F648A-IP; DIP-18_W7.62mm_Socket_LongPads
U3: TXB0108DQSR; CJMCU TXB0108 Arduino
XA1: Conn_Poncho2P_2x_20x2; Conn_Poncho_Completo

Connections:
+3.3VA: XA1.41
+3V3: A1.13 (~RST), A1.14 (~SLP), A2.13 (~RST), A2.14 (~SLP), A3.13 (~RST), A3.14 (~SLP), U3.5 (VCCA), XA1.1
+5V: C7.1, J4.1, J4.3, J4.5, J5.1, J5.3, J5.5, J6.1, J6.3, J6.5, R1.2, U2.14 (VDD), U3.16 (VCCB), XA1.2
+5VA: XA1.42
+12V: A1.8 (VMOT), A2.8 (VMOT), A3.8 (VMOT), C1.2, C2.2, C3.2, C5.1, J7.2, U1.3 (VO)
/reg12: U2.2 (CMP1/AN3/RA3), U3.12 (B7)
GND: A1.1 (GND), A2.1 (GND), A3.1 (GND), C1.1, C2.1, C3.1, C4.2, C5.2, C7.2, J7.3, J9.2, U1.2 (GND), U2.5 (VSS), U3.15 (GND), XA1.3, XA1.44
unnamed: A1.3 (A2), J1.2
unnamed: A1.4 (A1), J1.1
unnamed: A1.5 (B1), J1.3
unnamed: A1.6 (B2), J1.4
unnamed: A1.10 (M0), J6.2
unnamed: A1.11 (M1), J6.4
unnamed: A1.12 (M2), J6.6
unnamed: A1.15 (STEP), XA1.72
unnamed: A1.16 (DIR), XA1.74
unnamed: A2.3 (A2), J2.2
unnamed: A2.4 (A1), J2.1
unnamed: A2.5 (B1), J2.3
unnamed: A2.6 (B2), J2.4
unnamed: A2.10 (M0), J5.2
unnamed: A2.11 (M1), J5.4
unnamed: A2.12 (M2), J5.6
unnamed: A2.15 (STEP), XA1.76
unnamed: A2.16 (DIR), XA1.78
unnamed: A3.3 (A2), J3.2
unnamed: A3.4 (A1), J3.1
unnamed: A3.5 (B1), J3.3
unnamed: A3.6 (B2), J3.4
unnamed: A3.10 (M0), J4.2
unnamed: A3.11 (M1), J4.4
unnamed: A3.12 (M2), J4.6
unnamed: A3.15 (STEP), XA1.80
unnamed: A3.16 (DIR), XA1.75
unnamed: C4.1, J9.1, U1.1 (VI)
unnamed: J7.1, XA1.73
unnamed: J8.1, U2.17 (AN0/RA0)
unnamed: J8.2, U2.18 (AN1/RA1)
unnamed: J8.3, U2.16 (CLKIN/OSC1/RA7)
unnamed: J8.4, U2.15 (CLKOUT/OSC2/RA6)
unnamed: J8.5, U2.10 (RB4/PGM)
unnamed: J8.6, U2.11 (RB5)
unnamed: J8.7, U2.12 (RB6/T1OSC0/T1CKI/PGC)
unnamed: J8.8, U2.13 (RB7/T1OSI/PGD)
unnamed: R1.1, U2.4 (~MCLR~/Vpp/RA5)
unnamed: U2.6 (RB0/INT), U3.17 (B4)
unnamed: U2.7 (RB1/RX/DT), U3.18 (B3)
unnamed: U2.8 (RB2/TX/CK), U3.19 (B2)
unnamed: U2.9 (RB3/CCP1), U3.20 (B1)
unnamed: U3.2 (A2), XA1.34
unnamed: U3.3 (A3), XA1.31
unnamed: U3.4 (A4), XA1.32
unnamed: U3.7 (A5), XA1.29
unnamed: U3.9 (A7), XA1.33

Notes on the sheet:
Regulador de tension
Servo
Regulador para conectar el teclado y el display i2c
Drivers de motores pap
Pic encagado del teclado

Board: 12 copper layers, 23 parts (0 on the bottom side), 52 nets.

## Commit log

2020-07-04 Create README.md
    TP Final : Diseño de Circuitos Impresos
    Poncho Drivers EDU-CIAA.
    Pensado para el manejo de motores PAP, con el fin de diseñar un prototipo, de un maquina destinada
    para doblar alambre / caños.
    Se diseñar una placa, para implementar la utilización de tres drivers, destinada al manejo de motores
    paso a paso y a su ves, se deja dispuesto un conector par la utilizacion de un teclado, para comunicarse
2020-07-04 Create README.md
    TP Final : Diseño de Circuitos Impresos
    Poncho Drivers EDU-CIAA.
    Pensado para el manejo de motores PAP, con el fin de diseñar un prototipo, de un máquina destinada para doblar alambre
    / caños.
    Se diseñar una placa, para implementar la utilización de tres drivers,destinada al manejo de motores paso a paso y a su vez,
    se deja dispuesto un conector par la utilización de un teclado, para comunicarse con la dobladora de alambre. Por dicho
